<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F103_FreeRTOS_lwIP.ewp</path>
  </project>
  <batchBuild />
</workspace>
